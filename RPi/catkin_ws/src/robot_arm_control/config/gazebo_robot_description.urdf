Commit message: Att

File: RPi/catkin_ws/src/robot_arm_control/config/gazebo_robot_description.urdf (robot description, URDF)
Before this commit: robot robot_description, 11 links, 10 joints
Links:
- link camera_link: mass None -> 0.1
- link depth_camera_link: mass None -> 0.1
